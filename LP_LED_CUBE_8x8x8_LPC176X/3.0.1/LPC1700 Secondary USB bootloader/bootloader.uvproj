# Keil uVision project bootloader.uvproj, settings and files
target Bootloader LPC1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c include: .\common\inc;.\iap;.\msc;.\usb
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Docs
    ./: Abstract.txt
  group Startup
    ./common/src/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s
  group Diskimg
    ./msc/: DiskImg.c
  group USB
    ./msc/: mscuser.c
    ./usb/: usbcore.c usbdesc.c usbhw.c usbuser.c
  group IAP
    ./iap/: sbl_iap.c
  group App
    ./msc/: memory.c
