# Keil uVision project Http_upload.uvproj, settings and files
target LP LED CUBE 8x8x8 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LP_LED_CUBE_8x8x8 +hex
  AfterMake: fromelf --bin ".\Obj\LP_LED_CUBE_8x8x8.axf" --output ".\Flash 0x2000\LP_LED_CUBE_8x8x8_LPC176X_V301.bin"
  c flags: Optim=4
  c include: ..\LP_LED_CUBE_8x8x8_LPC176X;.\Libraries
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp admins.cgi directory.cgi index.cgi javascript.js network.cgi status_led_blue.png status_led_green.png status_led_red.png status_led_yellow.png style.css time.cgi users.cgi
  group Source Files
    ./: MAIN.c HTTP_CGI.c FTP_uif.c HTTP_err.c HTTP_uif.c PROTOCOL.c TCP_USERS.c
    ./Web/: WEB.C
    ./Libraries/: LED_CUBE_8x8x8.c
  group Configuration Files
    ./: Net_Config.c File_Config.c startup_LPC17xx.s FS_SPI_FlashPrg.c Retarget.c
  group Libraries
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib FS_CM3.lib
    ./Libraries/: ADC.c DELAY.c EMAC_DP83848.c HELP.c I2C.c SPI_LPC17xx.c system_LPC17xx.c UART.c TLC59116.c SETTINGS.c RTC.c SNTP.c ADMINS.c USERS.c
  group Documentation
    ./: Abstract.txt
