# Keil uVision project Http_upload.uvproj, settings and files
target LP LED CUBE 8x8x8 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LP_LED_CUBE_8x8x8 +hex
  AfterMake: fromelf --bin ".\Obj\LP_LED_CUBE_8x8x8.axf" --output ".\Flash 0x2000\LP_LED_CUBE_8x8x8_LPC176X_V400_TEST.bin"
  c flags: Optim=4
  c include: ..\LP_LED_CUBE_8x8x8_LPC176X_TEST;.\Libraries
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: MAIN.c
    ./Libraries/: LED_CUBE_8x8x8.c LED_CUBE_8x8x8_Animations.c LED_CUBE_8x8x8_Translation.c LED_CUBE_8x8x8_Rotation.c
  group Configuration Files
    ./: startup_LPC17xx.s
  group Libraries
    ./Libraries/: HELP.c system_LPC17xx.c UART.c DELAY.c
  group Documentation
    ./: Abstract.txt
